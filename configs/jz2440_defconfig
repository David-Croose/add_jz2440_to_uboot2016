## configs/jz2440_spl_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_JZ2440=y
CONFIG_SYS_PROMPT="JZ2440 # "

CONFIG_SPL=y

CONFIG_NET_RANDOM_ETHADDR=y
```
